# Keil uVision project ucos.uvprojx, settings and files
target STM32F4xx_IN_RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,VECT_TAB_SRAM
  c include: ..\applications\inc;..\librarys\CMSIS\Include;..\librarys\CMSIS\Device\ST\STM32F4xx\Include;..\librarys\STM32F4xx_StdPeriph_Driver\inc;..\ucos\port;..\ucos\source;..\USER\INC
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group readme
    ../: readme.txt
    ../readme/: PinDef.h pwm.txt readme1.txt 测试帧.txt
  group Debug
    ../USER/SCR/: HardFaultProc.c
  group Config
    ../applications/inc/: os_cfg.h stm32f4xx_conf.h
    ../USER/INC/: m_config.h AppCfg.h
  group User
    ../USER/SCR/: main.c FramePack.c CommHandle.c Queue.c m_printf.c UserLib.c SimuI2C.c AppCRC.c FlashOpt.c AES.c Capher.c FirmwareUpdate.c WRProtect.c MX25L.c MX25_APP.c
    ../applications/src/: stm32f4xx_it.c
  group CPUDrv
    ../librarys/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
    ../USER/SCR/: UART.C InitHW.c Timer.c RTC.c CPUID.c
  group startup
    ../librarys/CMSIS/Device/ST/STM32F4xx/Source/arm/: startup_stm32f4xx.s
  group STM32F4xx_Libs
    ../librarys/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_rng.c stm32f4xx_pwr.c stm32f4xx_syscfg.c
  group UCOS_PORT
    ../ucos/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg_r.c
  group UCOS_II
    ../ucos/source/: ucos_ii.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
target STM32F4xx_IN_FLASH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot +hex
  AfterMake: .\bincrc.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
